## integration/tester/testcase.yaml
```yaml
common:
  tags: integration
  integration_platforms:
    - nrf52dk_nrf52832

tests:
  integration.test_case:  
    harness: ztest
```
